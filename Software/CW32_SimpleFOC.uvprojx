# Keil uVision project CW32_SimpleFOC.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32F030C8 WHXY
  pack: WHXY.CW32F030_DFP.1.0.3
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CW32_SimpleFOC
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries\inc;.\BSP\inc;.\User\inc;.\FreeRTOS\include;.\FreeRTOS\protable
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/src/: interrupts_cw32f030.c main.c
  group Startup
    ./: startup_cw32f030.s
    ./Libraries/src/: system_cw32f030.c
  group Libraries
    ./Libraries/src/: cw32f030_adc.c cw32f030_atim.c cw32f030_awt.c cw32f030_btim.c cw32f030_crc.c cw32f030_debug.c cw32f030_digitalsign.c cw32f030_dma.c cw32f030_flash.c cw32f030_gpio.c cw32f030_gtim.c cw32f030_i2c.c cw32f030_iwdt.c cw32f030_lvd.c cw32f030_pwr.c cw32f030_ram.c cw32f030_rcc.c cw32f030_rtc.c cw32f030_spi.c cw32f030_systick.c cw32f030_uart.c cw32f030_vc.c cw32f030_wwdt.c
  group BSP
    ./BSP/src/: rcc.c led.c key.c delay.c
  group FreeRTOS/source
    ./FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/protable/: heap_4.c
  group FreeRTOS/portable
    ./FreeRTOS/protable/: port.c
software components: CMSIS:CORE 5.6.0
